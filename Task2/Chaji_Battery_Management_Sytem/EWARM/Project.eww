<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Chaji_Battery_Management_Sytem.ewp</path>
  </project>
  <batchBuild />
</workspace>
